## sdkconfig.defaults
```kconfig
CONFIG_ESP_WIFI_FTM_ENABLE=y
CONFIG_ESP_CONSOLE_USB_CDC=y
CONFIG_ESP_CONSOLE_USB_SERIAL_JTAG=y
```
